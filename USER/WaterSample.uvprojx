# Keil uVision project WaterSample.uvprojx, settings and files
target WaterSample (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769BITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: WaterSample +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,HAS_AWTK_CONFIG
  c misc: --gnu
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\CMSIS_RTOS;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\TOUCH;..\HARDWARE\SDMMC;..\HARDWARE\QSPI;..\awtk\src\ext_widgets;..\awtk;..\awtk\src;..\awtk\3rd;..\awtk\3rd\nanovg\base;..\awtk\3rd\nanovg;..\awtk\3rd\agge;..\awtk\3rd\libunibreak;..\awtk-port;..\FatFs\src;..\FatFs\src\drivers;..\awtk\3rd\gpinyin\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\WaterSample.sct
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f769xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/TOUCH/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/SDMMC/: sdmmc_sd.c
    ../HARDWARE/QSPI/: qspi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/CMSIS_RTOS
    ../CMSIS_RTOS/: cmsis_os.c
  group AWTK
    ../awtk/src/widgets/: app_bar.c button.c button_group.c check_button.c color_tile.c column.c combo_box.c combo_box_item.c dialog.c dialog_client.c dialog_title.c dragger.c edit.c grid.c group_box.c image.c label.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c tab_button.c tab_button_group.c tab_control.c view.c window.c calibration_win.c grid_item.c system_bar.c overlay.c
    ../awtk/src/base/: assets_manager.c bitmap.c canvas.c enums.c event_queue.c events.c font.c font_manager.c glyph_cache.c idle.c image_loader.c image_manager.c input_engine.c input_method.c layout.c lcd.c line_break.c locale_info.c main_loop.c rom_fs.c suggest_words.c system_info.c theme.c timer.c ui_builder.c velocity.c vgcanvas.c widget.c widget_animator.c widget_factory.c widget_vtable.c window_animator.c window_manager.c ui_loader.c font_loader.c window_base.c style.c style_const.c style_factory.c widget_animator_manager.c clip_board.c image_base.c input_device_status.c widget_animator_factory_null.c children_layouter.c self_layouter.c idle_info.c idle_manager.c timer_info.c timer_manager.c widget_pool.c lcd_profile.c dialog_highlighter.c dialog_highlighter_factory.c window_animator_factory.c children_layouter_factory.c hscrollable.c self_layouter_factory.c shortcut.c style_mutable.c text_edit.c
    ../awtk/src/tkc/: buffer.c color.c color_parser.c easing.c emitter.c fs.c matrix.c mem.c path.c rect.c str.c tokenizer.c utf8.c utils.c value.c wstr.c func_call_parser.c date_time.c time_now.c event.c slist.c object.c object_default.c named_value.c darray.c expr_eval.c int_str.c str_str.c
    ../awtk/src/blend/: image_g2d.c stm32_g2d.c soft_g2d.c blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/image_loader/: image_loader_stb.c
    ../awtk/src/lcd/: lcd_mem_bgra8888.c lcd_mem_rgb565.c lcd_mem_rgba8888.c lcd_mem_bgr565.c lcd_mem_bgr888.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/misc/: new.cpp
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/widget_animators/: widget_animator_scroll.c widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/: awtk_global.c
    ../awtk/src/font_loader/: font_loader_bitmap.c font_loader_stb.c
    ../awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
    ../awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/layouters/: children_layouter_default.c self_layouter_default.c children_layouter_builtins.c children_layouter_parser.c self_layouter_builtins.c self_layouter_parser.c self_layouter_menu.c
    ../awtk/src/ext_widgets/mutable_image/: mutable_image.c
    ../awtk/src/window_animators/: window_animator_builtins.c window_animator_center_scale.c window_animator_common.c window_animator_fade.c window_animator_htranslate.c window_animator_popdown.c window_animator_popup.c window_animator_slide.c window_animator_slide_down.c window_animator_slide_left.c window_animator_slide_right.c window_animator_slide_up.c window_animator_vtranslate.c
    ../awtk/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_default.c
    ../awtk/src/input_engines/: input_engine_pinyin.cpp
  group AWTK-PORT
    ../awtk-port/: main_loop_stm32_raw.c platform.c
    ../awtk/src/platforms/raw/: fs_os.c mutex_null.c
  group AWTK-DEMOS
    ../awtk/demos/: app_main.c window_calibration.c window_main.c window_record.c window_setting.c window_timing.c
  group LIBUNIBREAK
    ../awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
  group NANOVG
    ../awtk/3rd/nanovg/base/: nanovg.c
  group AGGE
    ../awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
  group EXT_WIDGETS
    ../awtk/src/ext_widgets/color_picker/: color_component.c color_picker.c rgb_and_hsv.c
    ../awtk/src/ext_widgets/guage/: guage.c guage_pointer.c
    ../awtk/src/ext_widgets/image_animation/: image_animation.c
    ../awtk/src/ext_widgets/keyboard/: candidates.c keyboard.c
    ../awtk/src/ext_widgets/rich_text/: rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c
    ../awtk/src/ext_widgets/scroll_view/: list_item.c list_view.c list_view_h.c scroll_bar.c scroll_view.c children_layouter_list_view.c
    ../awtk/src/ext_widgets/slide_view/: slide_view.c slide_indicator.c
    ../awtk/src/ext_widgets/switch/: switch.c
    ../awtk/src/ext_widgets/text_selector/: text_selector.c
    ../awtk/src/ext_widgets/time_clock/: time_clock.c digit_clock.c
    ../awtk/src/ext_widgets/: ext_widgets.c
    ../awtk/src/ext_widgets/progress_circle/: progress_circle.c
    ../awtk/src/ext_widgets/svg_image/: svg_image.c
    ../awtk/src/ext_widgets/gif_image/: gif_image.c
    ../awtk/src/ext_widgets/canvas_widget/: canvas_widget.c
    ../awtk/src/ext_widgets/image_value/: image_value.c
    ../awtk/src/ext_widgets/slide_menu/: slide_menu.c
    ../awtk/src/ext_widgets/mledit/: mledit.c line_number.c
    ../awtk/src/ext_widgets/scroll_label/: hscroll_label.c
  group gpinyin
    ../awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
  group FatFS
    ../FatFs/src/: diskio.c ff.c ff_gen_drv.c sd_diskio_dma_rtos.c
    ../FatFs/src/option/: cc936.c syscall.c
